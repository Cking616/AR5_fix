# Keil uVision project Project.uvprojx, settings and files
target FLASH (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AR5 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,__FPU_PRESENT ,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,CORE=CORE_CONTEX_M4,COMPILER=COMPILER_KIEL, __CC_ARM,USE_USB_OTG_FS
  c include: .\BasicLibrary;.\CMSISCore\Inc;.\CMSISDSP\Inc;.\STM32F4Driver\Inc;.\CSP;.\Component;.\Framework;.\Main;.\Packet;.\EntherCAT;.\canopen;.\STM32_MODBUS\modbus\ascii;.\STM32_MODBUS\modbus\functions;.\STM32_MODBUS\modbus\include;.\STM32_MODBUS\modbus\port;.\STM32_MODBUS\modbus\rtu;.\STM32_MODBUS\modbus\tcp;.\StateMachine;.\EtherCAT\Inc;.\SystemViewer;.\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSISCore
    ./CMSISCore/Sou/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group CMSISDSP
    ./CMSISDSP/Lib/: arm_cortexM4lf_math.lib
  group STM32F4Driver
    ./STM32F4Driver/Sou/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group Main
    ./Main/: stm32f4xx_it.c main.c CRC_16.c GlobalVariable.c JC2JDCommunication.c RS232_USART.c RS485_DMA.c RS485_JC2JD_ModBus.c RS485_USART.c DataInterface.c
  group FreeModbusSlave
    ./STM32_MODBUS/modbus/port/: RS485portserial.c porttimer.c portevent.c
    ./STM32_MODBUS/modbus/ascii/: mbascii.c
    ./STM32_MODBUS/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./STM32_MODBUS/modbus/rtu/: mbcrc.c mbrtu.c
    ./STM32_MODBUS/modbus/tcp/: mbtcp.c
    ./STM32_MODBUS/modbus/: mb.c
    ./STM32_MODBUS/: modbusCB.c
  group StateMachine
    ./StateMachine/: StateMachine.c StateMachine.h M1_statemachine.h M1_statemachine.c motor_structure.h Configuration.c Control.c Motor_Drive.c EEPROM_RW.c FLASH4_EEPROM.c
  group SystemViewer
    ./SystemViewer/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_NoOS.c
  group USB
    ./USB/: usbd_usr.c usbd_req.c usbd_ioreq.c usbd_desc.c usbd_core.c usbd_cdc_vcp.c usbd_cdc_core.c usb_dcd_int.c usb_dcd.c usb_core.c usb_bsp.c USB.c
target RAM (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: as above
  output: STM32F40_41xxx +hex
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: __FPU_PRESENT ,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,CORE=CORE_CONTEX_M4,COMPILER=COMPILER_KIEL,VECTTAB_RAM,VECT_TAB_SRAM
  c include: .\BasicLibrary;.\CMSISCore\Inc;.\CMSISDSP\Inc;.\STM32F4Driver\Inc;.\CSP;.\Component;.\Framework;.\Main;.\motor\inc;.\Packet;.\EntherCAT;.\EEPROM;.\STM32_MODBUS\modbus\include;.\STM32_MODBUS\modbus\ascii;.\STM32_MODBUS\modbus\port;.\STM32_MODBUS\modbus\tcp;.\STM32_MODBUS\modbus\rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F40_41xxx\STM32F40_41xxx.sct
